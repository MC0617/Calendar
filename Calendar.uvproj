# Keil uVision project Calendar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Calendar +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c DHT11.c DS1302.c main.c TM1640.c delay.h DHT11.h DS1302.h TM1640.h
